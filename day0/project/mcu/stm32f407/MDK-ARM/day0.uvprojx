# Keil uVision project day0.uvprojx, settings and files
target day0 (ARM-ADS)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  output: day0
  group app
    ../../../app/: control.cpp clamp.cpp motor_monitor.cpp arm.h clamp.h control.h motor_monitor.h
  group base
    ../../../base/: math.h motor.h
